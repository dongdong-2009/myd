# Keil uVision project 二氧化碳.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 环境温度控制 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Project
  group 源组 1
    ./Project/: main.c LCD1602.c SBQ.c
